#include <WiFi.h>
#include <esp_now.h>
#include <ESP32Servo.h>

const int ROTATE = 18;
const int PITCH = 19;
const int COCKER = 21;
const int TRIGGERER = 22;

Servo rotServo;
Servo pitServo;
Servo cocServo;
Servo triServo;

//shooting variables
enum Pow {COCK, SLACK, SHOOT, RELEASE};
Pow bang = COCK;
unsigned long cocking = 0;
unsigned long shooting = 0;

const int DEADZONE = 200;
bool lastClickState = HIGH;

typedef struct struct_message {
  int xValue;
  int yValue;
  int click;
} struct_message;

struct_message incomingData;
volatile boolean newDataRec = false;

void OnDataRecv (const esp_now_recv_info *info, const uint8_t *incomingDataPtr, int len) {
  memcpy(&incomingData, incomingDataPtr, sizeof(incomingData));

  newDataRec = true;
}

void setup() {
  Serial.begin(115200);
  delay(500);

  ESP32PWM::allocateTimer(0);
  ESP32PWM::allocateTimer(1);
  ESP32PWM::allocateTimer(2);
  ESP32PWM::allocateTimer(3);

  rotServo.attach(ROTATE);
  pitServo.attach(PITCH);
  cocServo.attach(COCKER);
  triServo.attach(TRIGGERER);

  delay(300);
  rotServo.write(90);
  delay(300);
  pitServo.write(135);
  delay(300);
  cocServo.write(0);
  delay(300);
  triServo.write(120);
  delay(300);

  WiFi.mode(WIFI_STA);

  if (esp_now_init() != ESP_OK) {
    Serial.println("Error initializing esp now");
    return;
  }

  esp_now_register_recv_cb(OnDataRecv);
}

void loop() {
  if (newDataRec) {
    newDataRec = false;

    int rawX = incomingData.xValue;
    int rawY = incomingData.yValue;

    if (incomingData.click == LOW && lastClickState == HIGH && bang == COCK) {
      cock();
    } else if (incomingData.click == LOW && lastClickState == HIGH && bang == SHOOT) {
      shoot();
    }
    if (millis() - cocking > 1000 && bang == SLACK) {
      slack();
    }
    if (millis() - shooting > 400 && bang == RELEASE) {
      release();
    }
    lastClickState = incomingData.click;

    int pitServoAngle = map(rawX, 4095, 0, 70, 160);
    pitServoAngle = constrain(pitServoAngle, 70, 160);
    pitServo.write(pitServoAngle);

    int rotServoAngle = map(rawY, 4095, 0, 0, 180);
    rotServoAngle = constrain(rotServoAngle, 0, 180);
    rotServo.write(rotServoAngle);
  }
}

void cock() {
  if (bang == COCK) {
    cocking = millis();
    cocServo.write(180);
    bang = SLACK;   
  }
}

void slack() {
  if (bang == SLACK) {
    cocServo.write(0);
    bang = SHOOT;
  }
}

void shoot() {
  if (bang == SHOOT) {
    shooting = millis();
    triServo.write(70);
    bang = RELEASE;
  }
}

void release() {
  if (bang == RELEASE) {
    triServo.write(120);
    bang = COCK;
  }
}